options:
  parameters:
    generate_options: qt_gui
    id: sweep_max_and_hold
    output_language: python
    title: sweep_max_and_hold
  states: {}

blocks:
- name: delay
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '20'
    value: '0'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: '217500000'
    step: '25000'
    stop: '222500000'
    value: '220000000'
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    start: '-2500000'
    step: '25000'
    stop: '2500000'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frequency
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: '1024'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: fft_max.out
    type: float
    vlen: '1024'
  states: {}
- name: blocks_multiply_const_xx_1
  id: blocks_multiply_const_xx
  parameters:
    const: 976562 * 0.000000001
    type: complex
    vlen: '1024'
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '1'
    vlen: '1024'
  states: {state: disabled}
- name: blocks_nlog10_ff_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: '1024'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: customModule_max2_0
  id: customModule_max2
  parameters:
    selector: 'True'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: window.WIN_HANN
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    nconnections: '2'
    vlen: '1024'
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_delay_0, '0']
- [blocks_add_xx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_xx_0, '0', soapy_hackrf_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_1, '0']
- [blocks_delay_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_xx_1, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_nlog10_ff_1, '0', customModule_max2_0, '0']
- [blocks_nlog10_ff_1, '0', qtgui_vector_sink_f_0, '1']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [customModule_max2_0, '0', blocks_file_sink_1, '0']
- [customModule_max2_0, '0', qtgui_vector_sink_f_0, '0']
- [fft_vxx_0, '0', blocks_multiply_const_xx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
