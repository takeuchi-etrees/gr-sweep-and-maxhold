options:
  parameters:
    generate_options: qt_gui
    id: fft_play
    output_language: python
    title: fft_play
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: fft_max.out
    repeat: 'True'
    type: float
    vlen: '1024'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate / 1024
    type: float
    vlen: '1024'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: '1024'
    x_start: '0'
    x_step: '1.0'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_vector_sink_f_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
